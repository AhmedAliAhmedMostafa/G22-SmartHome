# Keil uVision project poten.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: poten +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s LCD.h LCD.c main.c temp_sensor.c Delay.c Common_Macros.h Delay.h swicth.c port.c uart.c uart.h TM4C123GH6PM_B.h
    D:/: tm4c123gh6pm.h
    ../counter/: port.h
    ../keil project/: ADC.c ADC.h
